(* Generated automatically by TwinCAT - do not edit manually! *)
VAR_CONFIG
END_VAR
